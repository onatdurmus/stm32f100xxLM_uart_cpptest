# Keil uVision project uart_project_cplusp.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_project_cplusp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=2
  c misc: -fno-exceptions -fno-rtti
  c include: .\Drivers\header
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ../../../../../../Downloads/cpp_uart_test/: main.cpp
  group drivers_header
    ./Drivers/header/: stm32f100xxLM.hpp stm32f100xxLM_gpio.hpp stm32f100xxLM_rcc.hpp stm32f100xxLM_usart.hpp
  group drivers_source
    ./Drivers/source/: stm32f100xxLM_gpio.cpp stm32f100xxLM_rcc.cpp stm32f100xxLM_usart.cpp
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
